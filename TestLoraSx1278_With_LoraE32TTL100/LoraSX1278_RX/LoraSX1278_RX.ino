#include "SX1278.h"
#include "setup.h"

void setup()
{
  pinMode(PO_RF, OUTPUT);
  digitalWrite(PO_RF,LOW);
  
  pinMode(LORA_KEY_YT, INPUT_PULLUP);
  pinMode(LORA_KEY_BN, INPUT_PULLUP);

  pinMode(LED_BATT, OUTPUT);
  pinMode(LED_YT, OUTPUT);
  pinMode(LED_BN, OUTPUT);
  
  digitalWrite(LED_YT,0);
  digitalWrite(LED_BN,0);
  digitalWrite(LED_BATT,1);
  
  pinMode(VBAT, INPUT);
  pinMode(Rung, OUTPUT);
  digitalWrite(Rung,LOW);
  ADMUX = 0xc0;
  
  // Open serial communications and wait for port to open:
  Serial.begin(9600);
  FN_INIT_RF();
  Serial.println(F("Module Nguoi Nha. "));
  Serial.print(F("Dia chi nguon:="));Serial.println(LORA_ADDRESS);
  Serial.println();
  
//  attachInterrupt(0, FN_Interrupt0, LOW);
//  attachInterrupt(1, FN_Interrupt1, LOW);

//  byte st0;
////  st0 = sx1278.readRegister(REG_PREAMBLE_DETECT);
////  Serial.println(st0,HEX); 
//  st0 = sx1278.readRegister(REG_OP_MODE);
//  Serial.println(st0,HEX);    
//  sx1278.writeRegister(REG_OP_MODE, LORA_STANDBY_MODE);  
//  sx1278.writeRegister(REG_PREAMBLE_DETECT, 0xAA);
//  st0 = sx1278.readRegister(REG_PREAMBLE_DETECT);
//  Serial.println(st0,HEX); 
//
//  sx1278.writeRegister(REG_DIO_MAPPING1, 0x00);
//  sx1278.writeRegister(REG_DIO_MAPPING2, 0xff);
//  
//   sx1278.writeRegister(REG_IRQ_FLAGS_MASK, 0x01);
//  
//  st0 = sx1278.readRegister(REG_DIO_MAPPING2);
//  Serial.println(st0,HEX);  
////  sx1278.writeRegister(REG_OP_MODE, LORA_SLEEP_MODE);
////  sx1278.writeRegister(REG_OP_MODE, LORA_STANDBY_MODE);
////  sx1278.writeRegister(REG_OP_MODE, LORA_RX_MODE); 
//  sx1278.writeRegister(REG_OP_MODE, 0x85);
  sx1278.receive();
  delay(100);
  
}

int check_BN=1;
int check_YTA=1;
uint8_t state = 2;
uint8_t state_f = 2;
byte value;
byte header = 0;
boolean forme = false;
unsigned long previous; 
uint8_t _hreceived;
uint8_t _destination;
uint8_t _source;

void loop(void)
{
//  while(1);
    value = sx1278.readRegister(REG_IRQ_FLAGS);
    if( bitRead(value, 4) == 1 )
    {
      
      header = sx1278.readRegister(REG_FIFO_RX_BYTE_ADDR);
      
      if( header != 0 )
      {         
        _destination = sx1278.readRegister(REG_FIFO);
        _source = sx1278.readRegister(REG_FIFO);
      } 
      if(SX1278_debug_mode>0){
        Serial.print("header::");Serial.println(header);
        Serial.print("destination::");Serial.println(_destination);
        Serial.print("source::");Serial.println(_source);
      }
      state = sx1278.getPacket();  
      state = sx1278.setACK();
      state = sx1278.sendWithTimeout(); 
      for (unsigned int i = 0; i < sx1278.packet_received.length; i++) {
        my_packet[i] = (char)sx1278.packet_received.data[i]; 
      }
      if(SX1278_debug_mode>0){
          for(int i=0;i<16;i++)
            {
              Serial.print(my_packet[i]);
            }
            Serial.println();
      } 
      my_packet_send_mega[0]='@';
      if(_source==4){
        my_packet_send_mega[1]=my_packet[0];
        my_packet_send_mega[2]=my_packet[1];
        my_packet_send_mega[3]=my_packet[2];
        my_packet_send_mega[4]=my_packet[3];
        my_packet_send_mega[5]=my_packet[4];
        my_packet_send_mega[6]=my_packet[5];
        my_packet_send_mega[7]=my_packet[6];
        my_packet_send_mega[8]=my_packet[7];
      }
      else if(_source==5){
        my_packet_send_mega[9]=my_packet[0];
        my_packet_send_mega[10]=my_packet[1];
        my_packet_send_mega[11]=my_packet[2];
        my_packet_send_mega[12]=my_packet[3];
        my_packet_send_mega[13]=my_packet[4];
        my_packet_send_mega[14]=my_packet[5];
        my_packet_send_mega[15]=my_packet[6];
        my_packet_send_mega[16]=my_packet[7];
      }
      if(SX1278_debug_mode>0){
        for(int i=0;i<=16;i++)
        {
          Serial.print(my_packet_send_mega[i]);
        }
        Serial.println();
      }
      for(int i=0;i<=16;i++)
        {
          Serial.write(my_packet_send_mega[i]); // 40 30 32 37 30 32 38 00 00 31 35 31 32 33 33 01 50 

        }

        if(my_packet_send_mega[7]==0x01 || my_packet_send_mega[15]==0x01)
        {
          Serial.println("ON-OFF");
          digitalWrite(LED_BATT,0);
          delay(100);
          digitalWrite(LED_BATT,1);
        }




      sx1278.receive(); 
    } 
}

void FN_INIT_RF(void)
{
  // Power ON the module
  if (sx1278.ON() == 0){
    Serial.println(F("Setting power ON: SUCCESS "));
  } else {
    Serial.println(F("Setting power ON: ERROR "));
  }

  // Set transmission mode and print the result
  if (sx1278.setMode(LORA_MODE) == 0) {
    Serial.println(F("Setting Mode: SUCCESS "));
  } else {
    Serial.println(F("Setting Mode: ERROR "));
  }

  // Set header
  if (sx1278.setHeaderON() == 0) {
    Serial.println(F("Setting Header ON: SUCCESS "));
  } else {
    Serial.println(F("Setting Header ON: ERROR "));
  }

  // Select frequency channel
  if (sx1278.setChannel(LORA_CHANNEL) == 0) {
    Serial.println(F("Setting Channel: SUCCESS "));
  } else {
    Serial.println(F("Setting Channel: ERROR "));
  }

  // Set CRC
  if (sx1278.setCRC_ON() == 0) {
    Serial.println(F("Setting CRC ON: SUCCESS "));
  } else {
    Serial.println(F("Setting CRC ON: ERROR "));
  }

  // Select output power (Max, High, Intermediate or Low)
  if (sx1278.setPower('M') == 0) {
    Serial.println(F("Setting Power: SUCCESS "));
  } else {
    Serial.println(F("Setting Power: ERROR "));
  }

  // Set the node address and print the result
  if (sx1278.setNodeAddress(LORA_ADDRESS) == 0) {
    Serial.println(F("Setting node address: SUCCESS "));
  } else {
    Serial.println(F("Setting node address: ERROR "));
  }
  // Print a success message
  Serial.println(F("sx1278 configured finished"));
  Serial.println();

  // Get registers
  if(SX1278_debug_mode>0)
  {
    e = sx1278.getRegs();
    Serial.print(F("Getting Registers: state ")); 
    Serial.println(e);
  
    // Check status
    if( e == 0 ) 
    {    
      // 1. Power
      Serial.print(F("--> Power is ('M'=0x0F; 'L'=0x00; 'H'=0x07): 0x"));  
      Serial.print(sx1278._power);  
      Serial.println();
  
      // 2. Channel
      Serial.print(F("--> Channel is: 0x"));    
      Serial.print(sx1278._channel, HEX);  
      Serial.println();
  
      // 3. CRC
      Serial.print(F("--> CRC (CRC_ON=1; CRC_OFF=0): "));
      Serial.println(sx1278._CRC,DEC); 
  
      // 4. Header
      Serial.print(F("--> Header (HeaderON=0; HeaderOFF=1): "));
      Serial.println(sx1278._header,DEC);
  
      // 5. Preamble length
      Serial.print(F("--> Preamble length: "));
      Serial.println(sx1278._preamblelength,DEC);
  
      // 6. Payload length
      Serial.print(F("--> Payload Length is: "));    
      Serial.println(sx1278._payloadlength,DEC); 
  
      // 7. Node Address
      Serial.print(F("--> Node Address is: "));    
      Serial.println(sx1278._nodeAddress,DEC);  
          
      // 8. Max current
      Serial.print(F("--> Max current is (mA): "));    
      Serial.println(sx1278._maxCurrent,DEC);  
          
      // 9. Temperature
      Serial.print(F("--> Temperature is: "));
      Serial.print(sx1278._temp);
    }
  }
}
