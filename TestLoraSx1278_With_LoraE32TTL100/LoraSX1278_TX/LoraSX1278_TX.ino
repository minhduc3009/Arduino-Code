#include "SX1278.h"
#include "setup.h"

void setup()
{
  
  pinMode(int0_wakeup, INPUT_PULLUP);
  pinMode(int1_wakeup, INPUT_PULLUP);

  pinMode(PO_RF, OUTPUT);
  digitalWrite(PO_RF,LOW);

  pinMode(LORA_KEY_YT, INPUT_PULLUP);
  pinMode(LORA_KEY_BN, INPUT_PULLUP);

//  pinMode(LED_BATT, OUTPUT);
//  pinMode(LED_YT, OUTPUT);
//  pinMode(LED_BN, OUTPUT);

  digitalWrite(LED_YT,0);
  digitalWrite(LED_BN,0);
  digitalWrite(LED_BATT,0);

  pinMode(VBAT, INPUT);
  pinMode(Rung, OUTPUT);
  analogWrite(Rung,0);
  
  ADMUX = 0xc0;

  Serial.begin(9600);
  
  FN_INIT_RF();

  Serial.println(F("Module Benh Nhan. "));
  Serial.print(F("Dia chi nguon:="));Serial.println(LORA_ADDRESS);
  Serial.print(F("Dia chi dich:="));Serial.println(LORA_SEND_TO_ADDRESS_NG_NHA);

  sx1278.setRetries(5);
  attachInterrupt(1, FN_Interrupt1, LOW);
  
}
unsigned long timerStart,timerEnd;
void loop()
{
  timerStart = millis();
  while(1) {
      FN_SENSOR_1();
      timerEnd = millis();
      if(timerEnd - timerStart > 1000 * 1) {
          break;
      }
  }

  timerStart = millis();
  while(1) {
      FN_SENSOR_2();
      timerEnd = millis();
      if(timerEnd - timerStart > 1000 * 1) {
          break;
      }
  }
  
  distance[0]=(byte)(average_1/100) + 0x30;
  distance[1]=(byte)((average_1/10)%10) +0x30;
  distance[2]=(byte)(average_1%10 ) + 0x30;
  distance[3]=(byte)(average_2/100) + 0x30;
  distance[4]=(byte)((average_2/10)%10) +0x30;
  distance[5]=(byte)(average_2%10 ) + 0x30;

  distance[0]=0x30;
  distance[1]=0x31;
  distance[2]=0x32;
  distance[3]=0x33;
  distance[4]=0x34;
  distance[5]=0x35;
  distance[6]=0x36;
  distance[7]=0x37;
  distance[8]=0x38;
  distance[9]=0x39;
  
  
  sx1278.sendPacketTimeoutACKRetries(LORA_SEND_TO_ADDRESS_NG_NHA,distance,2000);
//  for(int i=0;i<=3;i++)
//  {
//    Serial.print(distance[i],HEX);
//  }
//  Serial.println();
  if(FLAG_CHECK_BT_YT==1)
  {
    digitalWrite(LED_YT,1);
    digitalWrite(LED_BN,0);
    e = sx1278.sendPacketTimeoutACKRetries(LORA_SEND_TO_ADDRESS_NG_NHA,distance,2000);
    FLAG_CHECK_BT_YT=0;
    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
      FN_LED_CHECK_ACK_YT_OK();
      }
  }
    if(FLAG_CHECK_BT_BN==1)
  {
    digitalWrite(LED_BN,1);
    digitalWrite(LED_YT,0);
    e = sx1278.sendPacketTimeoutACKRetries(LORA_SEND_TO_ADDRESS_NG_NHA, message1,2000);
    FLAG_CHECK_BT_BN=0;
     if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
      FN_LED_CHECK_ACK_BN_OK();
      }
  }
//  enterSleep();
}

void FN_INIT_RF(void)
{
  // Power ON the module
  if (sx1278.ON() == 0){
    Serial.println(F("Setting power ON: SUCCESS "));
  } else {
    Serial.println(F("Setting power ON: ERROR "));
  }

  // Set transmission mode and print the result
  if (sx1278.setMode(LORA_MODE) == 0) {
    Serial.println(F("Setting Mode: SUCCESS "));
  } else {
    Serial.println(F("Setting Mode: ERROR "));
  }

  // Set header
  if (sx1278.setHeaderON() == 0) {
    Serial.println(F("Setting Header ON: SUCCESS "));
  } else {
    Serial.println(F("Setting Header ON: ERROR "));
  }

  // Select frequency channel
  if (sx1278.setChannel(LORA_CHANNEL) == 0) {
    Serial.println(F("Setting Channel: SUCCESS "));
  } else {
    Serial.println(F("Setting Channel: ERROR "));
  }

  // Set CRC
  if (sx1278.setCRC_ON() == 0) {
    Serial.println(F("Setting CRC ON: SUCCESS "));
  } else {
    Serial.println(F("Setting CRC ON: ERROR "));
  }

  // Select output power (Max, High, Intermediate or Low)
  if (sx1278.setPower('M') == 0) {
    Serial.println(F("Setting Power: SUCCESS "));
  } else {
    Serial.println(F("Setting Power: ERROR "));
  }

  // Set the node address and print the result
  if (sx1278.setNodeAddress(LORA_ADDRESS) == 0) {
    Serial.println(F("Setting node address: SUCCESS "));
  } else {
    Serial.println(F("Setting node address: ERROR "));
  }
  // Print a success message
  Serial.println(F("sx1278 configured finished"));
  Serial.println();
    // Get registers
  if(SX1278_debug_mode>0)
  {
    e = sx1278.getRegs();
    Serial.print(F("Getting Registers: state ")); 
    Serial.println(e);
  
    // Check status
    if( e == 0 ) 
    {    
      // 1. Power
      Serial.print(F("--> Power is ('M'=0x0F; 'L'=0x00; 'H'=0x07): 0x"));  
      Serial.print(sx1278._power);  
      Serial.println();
  
      // 2. Channel
      Serial.print(F("--> Channel is: 0x"));    
      Serial.print(sx1278._channel, HEX);  
      Serial.println();
  
      // 3. CRC
      Serial.print(F("--> CRC (CRC_ON=1; CRC_OFF=0): "));
      Serial.println(sx1278._CRC,DEC); 
  
      // 4. Header
      Serial.print(F("--> Header (HeaderON=0; HeaderOFF=1): "));
      Serial.println(sx1278._header,DEC);
  
      // 5. Preamble length
      Serial.print(F("--> Preamble length: "));
      Serial.println(sx1278._preamblelength,DEC);
  
      // 6. Payload length
      Serial.print(F("--> Payload Length is: "));    
      Serial.println(sx1278._payloadlength,DEC); 
  
      // 7. Node Address
      Serial.print(F("--> Node Address is: "));    
      Serial.println(sx1278._nodeAddress,DEC);  
          
      // 8. Max current
      Serial.print(F("--> Max current is (mA): "));    
      Serial.println(sx1278._maxCurrent,DEC);  
          
      // 9. Temperature
      Serial.print(F("--> Temperature is: "));
      Serial.print(sx1278._temp);
    }
  }
}
void FN_LED_CHECK_ACK_YT_OK(void)
{
  for(int i=0;i<4;i++)
  {
    digitalWrite(LED_YT,1);delay(100);
    digitalWrite(LED_YT,0);delay(100);
  }
}
void FN_LED_CHECK_ACK_BN_OK(void)
{
  for(int i=0;i<4;i++)
  {
    digitalWrite(LED_BN,1);delay(100);
    digitalWrite(LED_BN,0);delay(100);
  }
}

void FN_SENSOR_1()
{
  float sensorValue = analogRead(A1);
  float cm = 10650.08 * pow(sensorValue,-0.935) - 10;
//  Serial.print(cm);Serial.println(" (cm)");
  Value_Distance_1 = (int)cm;
  if(Value_Distance_Pre_1!=Value_Distance_1){
      total = total - readings[readIndex];
      readings[readIndex] = Value_Distance_1;
      // add the reading to the total:
      total = total + readings[readIndex];
      // advance to the next position in the array:
      readIndex = readIndex + 1;
      // if we're at the end of the array...
      if (readIndex >= numReadings) {
      // ...wrap around to the beginning:
      readIndex = 0;
      }
      // calculate the average:
      average_1 = 10+ (total / numReadings); // Tính giá trị nhịp tim
      if(average_1<20)average_1=20;
      else if(average_1>150)average_1=150;
  }
//  Serial.print("Distance :=");Serial.println(average);
  Value_Distance_Pre_1=Value_Distance_1;
}


void FN_SENSOR_2()
{
  float sensorValue = analogRead(A2);
  float cm = 10650.08 * pow(sensorValue,-0.935) - 10;
//  Serial.print(cm);Serial.println(" (cm)");
  Value_Distance_2 = (int)cm;
  if(Value_Distance_Pre_2!=Value_Distance_2){
      total = total - readings[readIndex];
      readings[readIndex] = Value_Distance_2;
      // add the reading to the total:
      total = total + readings[readIndex];
      // advance to the next position in the array:
      readIndex = readIndex + 1;
      // if we're at the end of the array...
      if (readIndex >= numReadings) {
      // ...wrap around to the beginning:
      readIndex = 0;
      }
      // calculate the average:
      average_2 = 10+ (total / numReadings); // Tính giá trị nhịp tim
      if(average_2<20)average_2=20;
      else if(average_2>150)average_2=150;
  }
//  Serial.print("Distance :=");Serial.println(average);
  Value_Distance_Pre_2=Value_Distance_2;
}
