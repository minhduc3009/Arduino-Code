#include "SX1278.h"
#include <SPI.h>

#include "wiring_private.h"
#include "pins_arduino.h"
#include <avr/sleep.h>
#include <avr/power.h>

#define LORA_MODE  4
#define LORA_CHANNEL  CH_6_BW_125
#define LORA_ADDRESS  3

#define LORA_SEND_TO_ADDRESS  4

#define LORA_KEY_1 A4
#define LORA_KEY_2 A5

#define LED_BATT A1
#define LED_YT A2
#define LED_BN A3

#define VBAT A0
#define Rung  5

#define PO_RF  4

#define int0_wakeup  2
#define int1_wakeup  3

int diachi_dich=0;

int buttonState1 = 0;
int buttonState2 = 0;

int e;
char my_packet[100];

char message1 [] = "Benh Nhan:01";//Benh Nhan: 01 
char message2 [] = "YTa";
//void FN_Interrupt0(void)
//{
//  /* This will bring us back from sleep. */
//  
//  /* We detach the interrupt to stop it from 
//   * continuously firing while the interrupt pin
//   * is low.
//   */
//   detachInterrupt(0);
//}
//void FN_Interrupt1(void)
//{
//  detachInterrupt(1);
//  buttonState1 = analogRead2(LORA_KEY_1);
//  buttonState2 = analogRead2(LORA_KEY_2);
//    Serial.println(buttonState1);
//  Serial.println(buttonState2);
//    if(buttonState1<=100){
//    digitalWrite(LED_YT,1);
//    e = sx1278.sendPacketTimeoutACK(4, message2,2000);
////    e = sx1278.sendPacketTimeoutACKRetries(4, message2,2000);
//    
//    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//    }
//    else{
//      
//    }
////    int check=1;
////    while(check==1){
//////    e = sx1278.sendPacketTimeout(5, message1);
////    e = sx1278.sendPacketTimeoutACK(5, message1,1000);
////    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
////      check=0;
////    }
////    Serial.println(F("While Sending..."));
////    }
//  }
//  else{
//    
//  }
//  if(buttonState2<=100){
//    digitalWrite(LED_BN,1);
//    e = sx1278.sendPacketTimeoutACK(4, message1,1000);
////    e = sx1278.sendPacketTimeoutACKRetries(4, message1,1000);
//    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//    }
//    else{
//      
//    }
//  }
//  
//   
//}
//void enterSleep(void)
//{
//  
//  /* Setup pin2 as an interrupt and attach handler. */
//  attachInterrupt(1, FN_Interrupt1, LOW);
//  delay(100);
//  
//  set_sleep_mode(SLEEP_MODE_PWR_DOWN);
//  
//  sleep_enable();
//  
//  sleep_mode();
//  
//  /* The program will continue from here. */
//  
//  /* First thing to do is disable sleep. */
//  sleep_disable(); 
//}
void setup()
{
  pinMode(int0_wakeup, INPUT_PULLUP);
  pinMode(int1_wakeup, INPUT_PULLUP);
  
  pinMode(PO_RF, OUTPUT);
  digitalWrite(PO_RF,LOW);
  
  pinMode(LORA_KEY_1, INPUT_PULLUP);
  pinMode(LORA_KEY_2, INPUT_PULLUP);

  pinMode(LED_BATT, OUTPUT);
  pinMode(LED_YT, OUTPUT);
  pinMode(LED_BN, OUTPUT);
  
  digitalWrite(LED_YT,0);
  digitalWrite(LED_BN,0);
  digitalWrite(LED_BATT,0);
  
  pinMode(VBAT, INPUT);
  pinMode(Rung, OUTPUT);
  digitalWrite(Rung,LOW);
//  analogWrite(Rung,64);
  ADMUX = 0xc0;
  
//  // Open serial communications and wait for port to open:
    Serial.begin(9600);
//    cli();              // tắt ngắt toàn cục
//    
//    /* Reset Timer/Counter1 */
//    TCCR1A = 0;
//    TCCR1B = 0;
//    TIMSK1 = 0;
//    
//    /* Setup Timer/Counter1 */
//    TCCR1B |= (1 << WGM12) | (1 << CS11) | (1 << CS10); // prescale = 64 and CTC mode 4
//    OCR1A = 24999;              // initialize OCR1A
//    TIMSK1 = (1 << OCIE1A);     // Output Compare Interrupt Enable Timer/Counter1 channel A
//    sei();                      // cho phép ngắt toàn cục
//
  
  Serial.print(F("Address:"));
  Serial.println(LORA_ADDRESS);
  // Print a start message
  Serial.println(F("sx1278 module and Arduino: send two packets (One to an addrees and another one in broadcast)"));

  // Power ON the module
  if (sx1278.ON() == 0){
    Serial.println(F("Setting power ON: SUCCESS "));
  } else {
    Serial.println(F("Setting power ON: ERROR "));
  }

  // Set transmission mode and print the result
  if (sx1278.setMode(LORA_MODE) == 0) {
    Serial.println(F("Setting Mode: SUCCESS "));
  } else {
    Serial.println(F("Setting Mode: ERROR "));
  }

  // Set header
  if (sx1278.setHeaderON() == 0) {
    Serial.println(F("Setting Header ON: SUCCESS "));
  } else {
    Serial.println(F("Setting Header ON: ERROR "));
  }

  // Select frequency channel
  if (sx1278.setChannel(LORA_CHANNEL) == 0) {
    Serial.println(F("Setting Channel: SUCCESS "));
  } else {
    Serial.println(F("Setting Channel: ERROR "));
  }

  // Set CRC
  if (sx1278.setCRC_ON() == 0) {
    Serial.println(F("Setting CRC ON: SUCCESS "));
  } else {
    Serial.println(F("Setting CRC ON: ERROR "));
  }

  // Select output power (Max, High, Intermediate or Low)
  if (sx1278.setPower('M') == 0) {
    Serial.println(F("Setting Power: SUCCESS "));
  } else {
    Serial.println(F("Setting Power: ERROR "));
  }

  // Set the node address and print the result
  if (sx1278.setNodeAddress(LORA_ADDRESS) == 0) {
    Serial.println(F("Setting node address: SUCCESS "));
  } else {
    Serial.println(F("Setting node address: ERROR "));
  }
  // Print a success message
  Serial.println(F("sx1278 configured finished"));
  Serial.println();

  sx1278.setRetries(2);
  
}
float v_bat;
long randNumber;
void loop()
{ 
  Serial.println("Waitting....");
  if(diachi_dich > 0 && diachi_dich< 10){
    Serial.print("Dia chi dich:");
    Serial.println(diachi_dich);
    e = sx1278.sendPacketTimeoutACKRetries(diachi_dich, message2,2000);
//    e = sx1278.sendPacketTimeoutACKRetries(4, message2,2000);
    diachi_dich=0;
  }
  
//  Serial.println(diachi_dich);
//  buttonState1 = analogRead2(LORA_KEY_1);
//  buttonState2 = analogRead2(LORA_KEY_2);
//  
//  Serial.println(buttonState1);
//  Serial.println(buttonState2);
//  
//  Serial.println(ADMUX,BIN);
//    
//  v_bat=analogRead2(VBAT);
//  Serial.println(v_bat);
//  v_bat = map(v_bat, 0, 1023, 0,1100);
//  v_bat *= 4;
//  Serial.print("VBAT:=");Serial.print(v_bat);Serial.println("(mV)");

//  if(v_bat > 2900){
//    
//     digitalWrite(EA_PO,LOW);
//     digitalWrite(PO_RF,LOW);
//  }
//  else{
//    Serial.print("EA_PO-HIGH; PO_RF-HIGH;");
////    digitalWrite(EA_PO,HIGH);
//    delay(1);
//    digitalWrite(PO_RF,HIGH);
//  }


//  if(buttonState1<=100){
//    digitalWrite(LED_YT,1);
////    e = sx1278.sendPacketTimeoutACK(4, message2,2000);
//    e = sx1278.sendPacketTimeoutACKRetries(4, message2,2000);
//    
//    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//      digitalWrite(LED_YT,1);delay(100);
//      digitalWrite(LED_YT,0);delay(100);
//    }
//    else{
//      
//    }
////    int check=1;
////    while(check==1){
//////    e = sx1278.sendPacketTimeout(5, message1);
////    e = sx1278.sendPacketTimeoutACK(5, message1,1000);
////    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
////      check=0;
////    }
////    Serial.println(F("While Sending..."));
////    }
//  }
//  else{
//    
//  }
//  if(buttonState2<=100){
//    digitalWrite(LED_BN,1);
////    e = sx1278.sendPacketTimeoutACK(4, message1,1000);
//    e = sx1278.sendPacketTimeoutACKRetries(4, message1,1000);
//    if((e==0)||(e==4)||(e==5)||(e==6)||(e==7)){
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//      digitalWrite(LED_BN,1);delay(100);
//      digitalWrite(LED_BN,0);delay(100);
//    }
//    else{
//      
//    }
//  }



//  ///////////////////////////////
//  // 1. Get SNR
//  ///////////////////////////////  
//  e = sx1278.getSNR();
//
//  // check status
//  if( e == 0 ) 
//  {
//    Serial.print(F("Getting SNR \t\t--> OK. "));
//    Serial.print(F("SNR current value is: "));
//    Serial.println(sx1278._SNR);
//  }
//  else 
//  {
//    Serial.println(F("Getting SNR --> ERROR"));
//  } 
//
//  ///////////////////////////////
//  // 2. Get channel RSSI
//  ///////////////////////////////
//  e = sx1278.getRSSI();
//
//  // check status
//  if( e == 0 ) 
//  {
//    Serial.print(F("Getting RSSI \t\t--> OK. "));
//    Serial.print(F("RSSI current value is: "));
//    Serial.println(sx1278._RSSI);
//
//  }
//  else 
//  {
//    Serial.println(F("Getting RSSI --> ERROR"));
//  } 
//
//  ///////////////////////////////
//  // 3. Get last packet received RSSI
//  ///////////////////////////////
//  e = sx1278.getRSSIpacket();
//
//  // check status
//  if( e == 0 ) 
//  {
//    Serial.print(F("Getting RSSI packet \t--> OK. "));
//    Serial.print(F("Last packet RSSI value is: "));    
//    Serial.println(sx1278._RSSIpacket);
//  }
//  else 
//  {
//    Serial.println(F("Getting RSSI packet --> ERROR"));
//  } 
//  enterSleep();
  // Send message1 and print the result
//  e = sx1278.sendPacketTimeout(5, message1);
//  Serial.print(F("Packet sent, state "));
//  Serial.println(e, DEC);
//  e = sx1278.receivePacketTimeout(10000);
//  if (e == 0) {     
//    Serial.println(F("Package received!"));
//    for (unsigned int i = 0; i < sx1278.packet_received.length; i++) {
//      my_packet[i] = (char)sx1278.packet_received.data[i];
//    }
//    
//    Serial.print(F("Message: "));
//    Serial.println(my_packet);
//    
// //   delay(100);
////    sx1278.sendPacketTimeout(5, my_packet);
//    
//  } else {
//    Serial.print(F("Package received ERROR\n"));
//  }

//  delay(2000);  

//  // Send message2 broadcast and print the result
//  e = sx1278.sendPacketTimeout(4, message1);
//  Serial.print(F("Packet sent, state "));
//  Serial.println(e, DEC);
// 
// randNumber = random(2000,4000);
//  delay(randNumber);  
}

int analogRead2(uint8_t pin)
{
  uint8_t low, high;

#if defined(analogPinToChannel)
#if defined(__AVR_ATmega32U4__)
  if (pin >= 18) pin -= 18; // allow for channel or pin numbers
#endif
  pin = analogPinToChannel(pin);
#elif defined(__AVR_ATmega1280__) || defined(__AVR_ATmega2560__)
  if (pin >= 54) pin -= 54; // allow for channel or pin numbers
#elif defined(__AVR_ATmega32U4__)
  if (pin >= 18) pin -= 18; // allow for channel or pin numbers
#elif defined(__AVR_ATmega1284__) || defined(__AVR_ATmega1284P__) || defined(__AVR_ATmega644__) || defined(__AVR_ATmega644A__) || defined(__AVR_ATmega644P__) || defined(__AVR_ATmega644PA__)
  if (pin >= 24) pin -= 24; // allow for channel or pin numbers
#else
  if (pin >= 14) pin -= 14; // allow for channel or pin numbers
#endif

#if defined(ADCSRB) && defined(MUX5)
  // the MUX5 bit of ADCSRB selects whether we're reading from channels
  // 0 to 7 (MUX5 low) or 8 to 15 (MUX5 high).
  ADCSRB = (ADCSRB & ~(1 << MUX5)) | (((pin >> 3) & 0x01) << MUX5);
#endif
  
  // set the analog reference (high two bits of ADMUX) and select the
  // channel (low 4 bits).  this also sets ADLAR (left-adjust result)
  // to 0 (the default).
#if defined(ADMUX)
#if defined(__AVR_ATtiny25__) || defined(__AVR_ATtiny45__) || defined(__AVR_ATtiny85__)
  ADMUX = (analog_reference << 4) | (pin & 0x07);
#else
//  ADMUX = (analog_reference << 6) | (pin & 0x07);
  ADMUX = (0 << 6) | (pin & 0x07);
  ADMUX = ADMUX | 0xc0;
#endif
#endif

  // without a delay, we seem to read from the wrong channel
  //delay(1);

#if defined(ADCSRA) && defined(ADCL)
  // start the conversion
  sbi(ADCSRA, ADSC);

  // ADSC is cleared when the conversion finishes
  while (bit_is_set(ADCSRA, ADSC));

  // we have to read ADCL first; doing so locks both ADCL
  // and ADCH until ADCH is read.  reading ADCL second would
  // cause the results of each conversion to be discarded,
  // as ADCL and ADCH would be locked when it completed.
  low  = ADCL;
  high = ADCH;
#else
  // we dont have an ADC, return 0
  low  = 0;
  high = 0;
#endif

  // combine the two bytes
  return (high << 8) | low;
}
void serialEvent(){
  if (Serial.available()>0) 
  {
    char inChar =Serial.read();
    Serial.write(inChar);
    diachi_dich=(int)inChar-48;
////    if(inChar==0x00 && FLAG_DATA_START==0)
//    if(FLAG_DATA_START==0)
//    {
////      index=0;
//      FLAG_DATA_START = 1;
//      
//    }
//    if(FLAG_DATA_START==1 && FLAG_CHECK_232==0 && index < length_data_reciver)
//    {
//      data_reciver[index]=inChar;
//      index++;
//    }
//    if(index >= length_data_reciver){
////        Serial.write('@');
////        Serial.write('1');
////      for(int i=0;i<length_data_send;i++) //0-31
////      {
////        Serial.write(data_reciver[i]);
////      }
//      FLAG_DATA_START=0;
//    FLAG_CHECK_232=1;
//     index=0;
//
//    }
  }
}
